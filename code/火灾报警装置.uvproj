# Keil uVision project 火灾报警装置.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 火灾报警装置 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MQ-2.c LCD1602.c DS18B20.c Buzzer.c Motor.c HC-05.c main.c
